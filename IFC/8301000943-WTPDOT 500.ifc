Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 2dce184c-54da-4de0-a91c-800ae8aab741, NumberOfSaves: 35]
File name: Project Number
Time: 2024-01-25T11:36:23+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_2197662_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRS_57_AIR_UN_wall_diffuser_WTPD_Supply_Solid_Air:500, NLRS_57_AIR_UN_wall_diffuser_WTPD_Supply_Solid_Air:500:2197662
In: Default
Type - Description: Perforated supply grill for use in walls, Type WTPDO; PredefinedType: DIFFUSER; Material: Sendzimir verzinkt, RAL9010
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_wall_diffuser_WTPD_Supply_Solid_Air; SACS_Base_Index: 1000927
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - SACS_Plenum_C: 475 mm; SACS_Plenum_D: 198 mm; SACS_Plenum_E: 240 mm; SACS_Plenum_K: 144 mm; SACS_Plenum_L: 250 mm; SACS_Plenum_P: 418 mm
Type - General - Lookup_Article_Codes: WTPDO_Article_Codes; Lookup_Article_Data: WTPDO_Article_Data; Lookup_Article_Names: WTPDO_Article_Names; Lookup_Grill_Factors: WTPDO_Interpolation_Factors; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 2019-11-14; SACS_Revision_Number: 2.0
Type - Identity Data - Assembly Code: 57.00; Cost: 0; Description: Perforated supply grill for use in walls, Type WTPDO; Manufacturer: Solid Air Climate Solutions; Model: WTPDO; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 2019-11-14; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 2.0; NLRS_C_description: Perforated supply grill for use in walls, Type WTPDO; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Comments: Please make sure flow is set to m3/h! Throw, Pressure loss and sound are by interpolation!; Type Name: 500; URL: https://solid-air.nl/producten/roosters/wand-en-doorvoerroosters/wandroosters/wtpd-wrpd
Type - Materials and Finishes - SACS_Plenum_Material: Sendzimir verzinkt
Type - Mechanical - Flow - Max Flow: 100 dm3/s; Min Flow: 40 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 500; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_wall_diffuser_WTPD_Supply_Solid_Air; Family and Type: NLRS_57_AIR_UN_wall_diffuser_WTPD_Supply_Solid_Air: 500; Type: 500; Type Id: 2197639
Model Properties - (0) Connector Back (Default): no; (1) Connector Left: yes; (2) Connector Right: no; Connection side (0-2): 1; SACS_Color_Ral: yes; SACS_Lined_Plenum: yes; SACS_Standard_Color: yes; Wall Thickness (Standard = 110): 110 mm
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.994098 m2; NLRS_M_c01_diameter: 200 mm; SACS_Plenum_Length: 418 mm; Volume: 0.00227259 m3
Identity Data - Mark: 8684; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: WTPDOT 500; SACS_Article_Code: 8301000943; SACS_Gross_Cost: 240; SACS_Price_Version: 201906
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Material: RAL9010 Perforated; SACS_Flange_Material: RAL9010; SACS_Lining_Material: Armaflex; SACS_Lining_Thickness: 12 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_DbA: 28; SACS_Max_Ploss: 35 Pa; SACS_Primairy_Air_Temperature: 15 C; SACS_Room_Temperature: 25 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0; SACS_Throw: 1 mm
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Flow out of default specification!
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Throw_Visible: yes; SACS_Warning_Disable: yes
